# Keil uVision project STM32F401xx.uvprojx, settings and files
target STM32F401xx (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F401CC STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F401xx +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  ..\MDK-ARM\Output\STM32F401xx.bin ..\MDK-ARM\Output\STM32F401xx.axf
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F401xx
  c misc: --C99
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\USER;..\..\SYSTEM\CONFIG;..\..\SYSTEM\FLASH;..\..\SYSTEM\MAG;..\..\SYSTEM\GNSS;..\..\SYSTEM\MagCali;..\..\SYSTEM\COMMAND;..\..\SYSTEM\DELAY;..\..\SYSTEM\MagCaliOnline;..\..\Libraries\FreeRTOS\include;..\..\Libraries\FreeRTOS\portable;..\..\SYSTEM\USART-1;..\..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group MDK-ARM
    ../../Libraries/CMSIS/: system_stm32f4xx.c
    ../../Libraries/CMSIS/startup/: startup_stm32f401xx.s
  group STM32_lib
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../USER/: main.c stm32f4xx_it.c globals.c usr_FreeRTOS.h
    ../../SYSTEM/CONFIG/: config.c
    ../../Libraries/FreeRTOS/include/: FreeRTOSConfig.h
  group DELAY
    ../../SYSTEM/DELAY/: delay.c
  group USART
    ../../SYSTEM/USART-1/: USART.c
  group SPI
    ../../SYSTEM/MAG/: SPI1.c
  group FreeRTOS/Source
    ../../Libraries/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Port
    ../../Libraries/FreeRTOS/portable/: port.c portmacro.h heap_4.c
