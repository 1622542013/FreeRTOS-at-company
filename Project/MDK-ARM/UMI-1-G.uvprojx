# Keil uVision project UMI-1-G.uvprojx, settings and files
target STM32F401xx (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F401CC STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: umi-1-g-arm3 +hex
  AfterMake: E:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  ..\MDK-ARM\Output\umi-1-g-arm3.bin ..\MDK-ARM\Output\umi-1-g-arm3.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F401xx
  c misc: --C99
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\USER;..\..\SYSTEM\CONFIG;..\..\SYSTEM\FLASH;..\..\SYSTEM\USART;..\..\SYSTEM\MAG;..\..\SYSTEM\GNSS;..\..\SYSTEM\PROTOCOL
  memory RVCT4: ROM 0x8010000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group MDK-ARM
    ../../Libraries/CMSIS/startup/: startup_stm32f401xx.s
  group USER
    ../../USER/: main.c stm32f4xx_it.c globals.c
  group FWlib
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_spi.c
  group CMSIS
    ../../Libraries/CMSIS/: system_stm32f4xx.c
  group CONFIG
    ../../SYSTEM/CONFIG/: config.c
  group FLASH
    ../../SYSTEM/FLASH/: flash.c
  group USART
    ../../SYSTEM/USART/: usart.c
  group MAG
    ../../SYSTEM/MAG/: RM3100.c SPI1.c
  group GNSS
    ../../SYSTEM/GNSS/: gnss.c ublox.c
  group PROTOCOL
    ../../SYSTEM/PROTOCOL/: protocol.c
